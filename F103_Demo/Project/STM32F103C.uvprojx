# Keil uVision project STM32F103C.uvprojx, settings and files
target STM32F103C8T6 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103C +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\Mylib;..\Libraries;..\CM3;..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../User/: stm32f10x_it.c main.c
  group Mylib
    ../Mylib/: schedule.c board.c key.c delay.c time.c pwm.c Input.c SPI1.c SPI2.c TIM1.c ADC.c DRV8305.c AS5048a.c model_ident.c SVPWM.c Foc.c
  group Libraries
    ../Libraries/: misc.c stm32f10x_adc.c stm32f10x_can.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_exti.c stm32f10x_spi.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0
